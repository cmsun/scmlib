# Keil uVision project gyro.uvprojx, settings and files
target gyro (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gyro
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_DMP,EMPL,MPU6050,EMPL_TARGET_STM32F4,MPL_LOG_NDEBUG=0,STM32F407xx
  c include: ../Inc;              ../Drivers/STM32F4xx_HAL_Driver/Inc;              ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;              ../Drivers/CMSIS/Include;              ..\..\APP\BSP;              ..\..\APP\MPU\driver\eMPL;              ..\..\APP\MPU\driver\include;              ..\..\APP\MPU\driver\stm32;              ..\..\APP\MPU\eMPL-hal;              ..\..\APP\MPU\mllite;              ..\..\APP\MPU\mpl;              ..\..\APP\NMEALIB\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ./: startup_stm32f407xx.s
    ../Src/: main.c gpio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group APP/BSP
    ../../APP/BSP/: debug.c hmc5843.c MahonyAHRS.c mpuxxxx.c GPS.c iic.c
  group /APP/MPU
    ../../APP/MPU/mpl/: libmpllib.lib
    ../../APP/MPU/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../APP/MPU/driver/stm32/: log_stm32.c
    ../../APP/MPU/eMPL-hal/: eMPL_outputs.c
    ../../APP/MPU/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group /APP/NMEALIB
    ../../APP/NMEALIB/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
software components: CMSIS:CORE 5.1.2
