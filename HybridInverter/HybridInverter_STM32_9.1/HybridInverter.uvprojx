# Keil uVision project HybridInverter.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HybridInverter
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG
  c include: .\MSP;.\CMSIS;.\FWLIB\inc;.\USER;.\SYSTEM;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT;.\modbus\inc;.\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MSP
    ./MSP/: flash.c adc.c debug.c gpio.c usart.c systick.c timer.c iic.c rtc.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group USER
    ./USER/: main.c system_task.c
  group UCOSII
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm
  group MODBUS
    ./modbus/src/: byteorder.c mbascii.c mbchecksum.c mberror.c mbformat.c mbprocess.c mbrtu.c
    ./MODBUS/src/: modbus.c
  group BSP
    ./BSP/: eeprom.c
