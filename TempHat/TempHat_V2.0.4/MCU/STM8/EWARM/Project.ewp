# IAR project Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\STM8S_StdPeriph_Driver\inc; ..\..\..\APP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG; STM8S003
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\APP; ..\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc
  ILINK.IlinkOutputFile: Project.out
  group APP
    ../../../APP/: analog.c analog.h configure.c digitron.c digitron.h fan.c fan.h filter.c filter.h iic.c iic.h iwdg.c iwdg.h key.c key.h led.c led.h main.c pid.c pid.h power.c power.h pwm.c pwm.h stdbool.h stdint.h TempManage.c TempManage.h tick.c tick.h
  group STM8S_StdPeriph_Driver
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group User
    ./: stm8s_conf.h stm8s_it.c stm8s_it.h
