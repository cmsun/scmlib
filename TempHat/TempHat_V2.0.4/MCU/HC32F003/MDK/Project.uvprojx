# Keil uVision project Project.uvprojx, settings and files
target TempHat (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ESEL ELITTLE
  output: output +hex
  c flags: OneElfS=1 uC99=1 wLevel=4
  c define: __WEAK=__weak
  c include: ..\MDK;..\common;..\driver\inc;..\..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ../common/: interrupts_hc32f005.c system_hc32f005.c startup_hc32f005.s base_types.h board_stkhc32f005.h hc32f005.h interrupts_hc32f005.h system_hc32f005.h
  group driver
    ../driver/src/: adc.c adt.c bgr.c bt.c crc.c ddl.c flash.c gpio.c i2c.c lpm.c lvd.c pca.c ram.c reset.c spi.c sysctrl.c trim.c uart.c vc.c wdt.c
  group APP
    ../../../APP/: analog.c analog.h digitron.c digitron.h fan.c fan.h filter.c filter.h iic.c iic.h iwdg.c iwdg.h key.c key.h led.c led.h main.c pid.c pid.h power.c power.h TempManage.c TempManage.h tick.c tick.h configure.h configure.c pwm.c pwm.h
software components: CMSIS:CORE 4.1.0
